File: ID_EEPROM.kicad_sch (KiCad schematic)
At the start: 2 parts, among them U2 M24C64

Commit message: finished schematic
Other:
- company: (none) -> Mini Moducard System
